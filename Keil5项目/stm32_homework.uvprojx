# Keil uVision project stm32_homework.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_homework
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\CMSIS;..\User;..\STM32F4xx_StdPeriph_Driver\inc;..\board_dev;..\middleware\ringbuffer;..\mcu_dev
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../User/: main.c stm32f4xx_it.c
  group board_dev
    ../board_dev/: board_key.c board_led.c board_uart1.c
  group SPL
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_rcc.c
  group mcu_dev
    ../mcu_dev/: mcu_tim11.c
  group middleware
    ../middleware/ringbuffer/: rb.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
